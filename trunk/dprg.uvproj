# Keil uVision project dprg.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: dprg
  c flags: Optim=1
  c include: ..\StellarisWare;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./: EncoderDemo.c IRSensorDemo.c LineSensorDemo.c MotorDemo.c ServoDemo.c UARTDemo.c
  group Main
    ./: RobzDemo.c Startup.s RobzDemo.h
  group External
    ../StellarisWare/driverlib/rvmdk/: driverlib.lib
    ../StellarisWare/utils/: uartstdio.c
  group RASLib
    ./RASLib/: encoder.c init.c linesensor.c motor.c servo.c timer.c encoder.h init.h linesensor.h motor.h servo.h timer.h uart.h
